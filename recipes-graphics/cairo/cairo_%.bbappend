PACKAGECONFIG:remove:nxp-ls1028 = "opengl"
DEPENDS:append:nxp-ls1028 = " libdrm"
