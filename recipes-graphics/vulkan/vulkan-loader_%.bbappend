RRECOMMENDS:${PN}:remove:nxp-ls1028  = "mesa-vulkan-drivers"
