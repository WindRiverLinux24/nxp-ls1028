COMPATIBLE_MACHINE:nxp-ls1028 = "nxp-ls1028"
SRCREV:nxp-ls1028 = "a0769e23304957a22f0cbeee6d1f547b20c3c21e"
