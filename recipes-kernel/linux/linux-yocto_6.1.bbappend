KBRANCH:nxp-ls1028  = "v6.1/standard/nxp-sdk-6.1/nxp-soc"

require linux-yocto-nxp-ls1028.inc
