require linux-yocto-nxp-ls1028.inc

KBRANCH_nxp-ls1028  = "v5.10/standard/nxp-sdk-5.10/nxp-soc"

