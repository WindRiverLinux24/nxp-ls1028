KBRANCH:nxp-ls1028  = "v5.15/standard/nxp-sdk-5.15/nxp-soc"

require linux-yocto-nxp-ls1028.inc
