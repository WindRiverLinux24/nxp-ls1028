KBRANCH:nxp-ls1028  = "v6.6/standard/preempt-rt/nxp-sdk-6.6/nxp-soc"

require linux-yocto-nxp-ls1028.inc
