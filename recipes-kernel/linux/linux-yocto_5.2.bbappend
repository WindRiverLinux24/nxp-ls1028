require linux-yocto-nxp-ls1028.inc

KBRANCH_nxp-ls1028  = "v5.2/standard/nxp-lsdk-20.04/nxp-ls1028"

